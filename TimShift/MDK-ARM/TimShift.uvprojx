# Keil uVision project TimShift.uvprojx, settings and files
target TimShift (6140000::V6.14::ARMCLANG)
  device: STM32G431RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TimShift +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G431xx,HSE_VALUE=25000000,USE_FULL_LL_DRIVER
  c include: ..\code\Drivers\CMSIS\core\Include;..\code\Inc;..\code\Drivers\STM32G4\inc;..\code\Drivers\LL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group driver/cmsis
    ../code/Drivers/CMSIS/Device/src/: system_stm32g4xx.c
    ./: startup_stm32g431xx.s
  group drver/stm32g
    ../code/Drivers/STM32G4/src/: stm32g4_gpio.c stm32g4_rcc.c stm32g4_uart.c
  group driver/LL
    ../code/Drivers/LL/: stm32g4xx_ll_tim.c stm32g4xx_ll_adc.c stm32g4xx_ll_dac.c stm32g4xx_ll_i2c.c stm32g4xx_ll_rcc.c stm32g4xx_ll_spi.c
  group src
    ../code/Src/: main.c stm32g4xx_it.c gpio.c uart.c rcc.c tim.c AD9102.c adc.c dac.c FilterHP.c i2c.c spi.c
software components: CMSIS:CORE 5.3.0
