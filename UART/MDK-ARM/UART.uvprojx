# Keil uVision project UART.uvprojx, settings and files
target UART (6090000::V6.9::.\ARMCLANG)
  device: STM32G431RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: UART +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G431xx
  c include: ..\code\Drivers\CMSIS\core\Include;..\code\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group code/cmsis
    ../code/Drivers/CMSIS/Device/src/: system_stm32g4xx.c startup_stm32g431xx.s
  group src
    ../code/Src/: main.c stm32g4xx_it.c gpio.c
software components: CMSIS:CORE 5.3.0
